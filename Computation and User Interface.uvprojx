# Keil uVision project Computation and User Interface.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Computation and User Interface
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: Main.c Main.h lcd.c lcd.h Arial_10pt.c Arial_10pt.h Arial_14pt.c Arial_14pt.h bitmap_db.h Planetary_Positioning.c Planetary_Positioning.h
    C:/Users/joels/Google Drive/Work/UNI/ELEC3885 Group Design Project/Project Partitions/Computation & Interface/Code/cmsis-core-k64f-master/cmsis-core-k64f/: system_MK64F12.h cmsis.h
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
